## tests/arch/arm/arm_psci/testcase.yaml
```yaml
tests:
  arch.arm64.psci:
    arch_allow: arm
    tags: arm psci
    filter: CONFIG_ARM_PSCI
```
